# Autodesk Inventor assembly: adaptest
## iProperties
Created: 2006-11
Part Number: adaptest
Document SubType Name: Assembly
Designer: WINDGES
Author: WINDGES
